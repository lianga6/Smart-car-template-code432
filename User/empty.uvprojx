# Keil uVision project empty.uvprojx, settings and files
target empty (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: MSP432P401R Texas Instruments
  pack: TexasInstruments.MSP432P4xx_DFP.3.2.6
  cpu: IROM(0x00000000,0x00040000) IROM2(0x00200000,0x00004000) IRAM(0x20000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: empty
  AfterMake: fromelf --bin --output .\Build\empty.bin .\Build\empty.axf
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: __MSP432P401R__,__FPU_PRESENT =1
  c include: ..\lib\inc;..\lib\Include;..\lib\rom\MSP432P4xx;..\lib\sys\CMSIS;..\lib\sys;..\lib\delay;..\lib\Clock;..\lib\USART;..\Hardware\LED;..\Hardware\timer;..\Hardware\KEY;..\Hardware\EXTI;..\Hardware\MPU6050\eMPL;..\Hardware\MPU6050;..\Hardware\OLED;..\lib\PID;..\Hardware\control;..\lib\PID_location;..\lib\business_process;..\Hardware\beep;..\Hardware\sensor;..\Hardware\HC_SR0;..\Hardware\BlueTooth;..\Hardware\JY901
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x200000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1000000 size 0x10000
  group Source
    ../: main.c system_msp432p401r.c
    ./: startup_msp432p401r_uvision.s
  group Library
    ../lib/msp432/: msp432p4xx_driverlib.lib
  group Hardware
    ../Hardware/LED/: led.c
    ../Hardware/timer/: timer.c
    ../Hardware/EXTI/: exti.c
    ../Hardware/KEY/: key.c
    ../Hardware/MPU6050/: mpu6050.c myiic.c
    ../Hardware/MPU6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../Hardware/OLED/: oled.c
    ../Hardware/control/: control.c
    ../Hardware/beep/: beep.c
    ../Hardware/sensor/: sensor.c
    ../Hardware/HC_SR0/: HC-SR0.c
    ../lib/USART/: headfile.h
    ../Hardware/BlueTooth/: BlueTooth.c
    ../Hardware/JY901/: JY901.c
  group system
    ../lib/delay/: delay.c
    ../lib/Clock/: clock.c
    ../lib/USART/: baudrate_calculate.c usart.c
    ../lib/PID/: PID.c
    ../lib/business_process/: business_process.c
software components: CMSIS:CORE 4.3.0
